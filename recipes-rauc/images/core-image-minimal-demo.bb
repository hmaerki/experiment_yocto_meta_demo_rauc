require recipes-core/images/core-image-minimal.bb

DESCRIPTION = "A small image including rauc"

# IMAGE_FEATURES += ""
IMAGE_INSTALL += "bc"
